<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\boiler_segmindicator_v01.210117.ewp</path>
  </project>
  <batchBuild/>
</workspace>


